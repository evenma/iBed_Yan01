# Keil uVision project Zuobianqi_V5B.uvproj, settings and files
target Zuobianqi_V5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2119 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Zuobianqi_V5B +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress=191
  c include: .\src\Kernel\include;.\src\Startup;.\src\Kernel\finsh;.\src\Kernel\libcpu\arm\lpc214x;.\src\Kernel\net\lwip\src\include;.\src\Kernel\net\lwip\src;.\src\Kernel\net\lwip\src\include\lwip;.\src\Kernel\net\lwip\src\arch\include;.\src\Kernel\net\lwip\src\include\ipv4;.\src\Kernel\filesystem\dfs\include;.\src\Kernel\filesystem\dfs;.\src;.\src\BSP;.\src\APP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group BSP
    ./src/BSP/CAN/: CAN.c CANAPP.c CANFUNC.c
    ./src/BSP/: SuReQi.c Adc.c pwm.c
  group Kernel
    ./src/Kernel/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Startup
    ./src/Startup/: board.c startup.c rtconfig.h
  group LPC214X
    ./src/Kernel/libcpu/arm/lpc214x/: cpu.c interrupt.c serial.c stack.c trap.c context_rvds.S start_rvds.S
  group Finsh
    ./src/Kernel/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group APP
    ./src/APP/: CanAnalyzer.c SmsApp.c ActionThread.c Sensor.c application.c
    ./src/: Common.c
